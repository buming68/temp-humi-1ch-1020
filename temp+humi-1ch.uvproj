# Keil uVision project temp+humi-1ch.uvproj, settings and files
target temphumi (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: temp+humi-1ch10C +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\SYSTEM;.\HARDWARE
  group USER
    ./USER/: main.c
  group HARDWARE
    ./HARDWARE/: timer.c uart.c flashrom.c i2c.c sht30.c
  group SYSTEM
    ./SYSTEM/: receservice.c config.c wdt.c
